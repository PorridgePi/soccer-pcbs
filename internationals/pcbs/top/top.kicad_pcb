File: internationals/pcbs/top/top.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: pcbs: top: feat: import dxf
Other:
- board outline added: 170 x 147 mm
